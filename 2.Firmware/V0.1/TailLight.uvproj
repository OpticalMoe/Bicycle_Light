# Keil uVision project TailLight.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: TailLight +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code
  group Source Group 1
    ./: STARTUP.A51
    ./Code/: light.c light.h main.c stc8gxx.h adc.c adc.h peripheral.c peripheral.h state.c state.h
